FILESEXTRAPATHS:prepend:platy := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:platy = "platy"
