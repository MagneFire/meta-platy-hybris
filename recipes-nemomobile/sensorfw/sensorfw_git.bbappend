DEPENDS:append:platy = " libhybris "
