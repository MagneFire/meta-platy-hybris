RDEPENDS:${PN}:append:platy = " qt5-qpa-hwcomposer-plugin "
