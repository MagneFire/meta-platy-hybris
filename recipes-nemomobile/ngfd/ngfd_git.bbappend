RDEPENDS:${PN}:append:platy = " ngfd-plugin-droid-vibrator "
