RDEPENDS:pulseaudio-server:append:platy = " pulseaudio-modules-droid "
