FILESEXTRAPATHS:prepend:platy := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:platy = " file://default.conf"
