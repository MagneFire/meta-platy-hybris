FILESEXTRAPATHS:prepend:platy := "${THISDIR}/${PN}:"
